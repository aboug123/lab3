# Keil uVision project ADCSWTrigger.uvprojx, settings and files
target ADCSWTrigger (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s alarm.c timers_init.c timers_init.h bool.h speaker.h speaker.c alarm.h
    ../../ValvanoWaveTM4C123v5/inc/: PLL.h tm4c123gh6pm.h ADCSWTrigger.h PLL.c ADCSWTrigger.c ST7735.h
    ../../ValvanoWaveTM4C123v5/ADCSWTrigger_4C123/: ADCTestMain.c
    ../../ValvanoWaveTM4C123v5/ST7735_4C123/: ST7735TestMain.c
software components: CMSIS:CORE 5.0.2
